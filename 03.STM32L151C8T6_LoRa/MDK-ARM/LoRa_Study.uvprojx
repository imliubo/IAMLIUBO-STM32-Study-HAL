# Keil uVision project LoRa_Study.uvprojx, settings and files
target LoRa_Study (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L151C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRa_Study
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xBA
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_uart.c stm32l1xx_hal_flash.c stm32l1xx_hal.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_tim.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_rcc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_cortex.c
  group Application/User
    ../Src/: stm32l1xx_it.c main.c stm32l1xx_hal_msp.c spi.c usart.c gpio.c SX1278.c
software components: CMSIS:CORE 4.1.0
